# IAR project fmc_ap_main.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: D:\project\M480_BSP_CMSIS_V3.03.001\Library\CMSIS\Include; D:\project\M480_BSP_CMSIS_V3.03.001\Library\Device\Nuvoton\M480\Include; D:\project\M480_BSP_CMSIS_V3.03.001\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fmc_ap_main.bin
  ILINK.IlinkOutputFile: fmc_ap_main.out
  ILINK.IlinkExtraOptions: --image_input Release\Exe\fmc_ld_code.bin,loaderImage1Base,.bin_image,4; --image_input Release\Exe\fmc_ld_code.bin,loaderImage1Limit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../project/M480_BSP_CMSIS_V3.03.001/Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../project/M480_BSP_CMSIS_V3.03.001/Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Library
    ../../../project/M480_BSP_CMSIS_V3.03.001/Library/StdDriver/src/: clk.c fmc.c gpio.c retarget.c sys.c uart.c
  group User
    ../: APROM_main.c
