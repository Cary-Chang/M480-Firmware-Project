# IAR project spi_mastermode.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: D:\project\NUC472_NUC442_BSP_CMSIS_V3.03.000\Library\CMSIS\Include; D:\project\NUC472_NUC442_BSP_CMSIS_V3.03.000\Library\Device\Nuvoton\NUC472_442\Include; D:\project\NUC472_NUC442_BSP_CMSIS_V3.03.000\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spi_mastermode.bin
  ILINK.IlinkOutputFile: spi_mastermode.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../project/NUC472_NUC442_BSP_CMSIS_V3.03.000/Library/Device/Nuvoton/NUC472_442/Source/IAR/: startup_NUC472_442.s
    ../../../project/NUC472_NUC442_BSP_CMSIS_V3.03.000/Library/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
  group Library
    ../../../project/NUC472_NUC442_BSP_CMSIS_V3.03.000/Library/StdDriver/src/: clk.c gpio.c retarget.c spi.c sys.c timer.c uart.c
  group User
    ../: main.c
